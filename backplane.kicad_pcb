# Repository dbrgn/ic880a-backplane

File README.md:

# iC880A + Raspberry Pi Backplane

*Buy this board at [shop.coredump.ch](https://shop.coredump.ch/product/ic880a-lorawan-gateway-backplane/)!*

This is a backplane to connect an iC880A-SPI concentrator board to a Raspberry
Pi. It is inspired by the [iC880A backplane by
@gonzalocasas](https://github.com/gonzalocasas/ic880a-backplane), but aims to
give you the following additional features:

Power

- Screw terminal and footprint for MP1584 step-down regulator module (6.7-28V)
- Screw terminal for direct power input/output (5V)
- Protection diode and resettable polyfuse against high voltage spikes
- Protection against reverse polarity power input

Headers

- Full access to Raspberry Pi GPIO header
- Pin header for serial communication (RX/TX)
- 2 Pin headers for I²C based sensors (SDA/SCL/GND/3.3V/5V)

Sensors

- A [SHT21](https://sensirion.com/sht21/) temperature/humidity sensor
- An MCP3425 16-bit ADC to measure RPi supply voltage

Other

- Pin header with flyback diode for 5V fan (5V/GND)
- General purpose button connected to GPIO pin (e.g. for controlled Raspi
  shutdown)
- Three general purpose SMD LEDs (Note: Only usable from Raspi versions
  with 40-pin GPIO header)
- Mounting holes for Raspberry Pi B+ / 2B / 3B / Zero

## PCB

## Schematics

See [schematics-v1.4.pdf](schematics-v1.4.pdf).

## Development

This PCB was created using KiCad 4.

Make sure that you clone all submodules:

    git submodule init
    git submodule update

## License

© 2017–2018 Danilo Bargen. Licensed under the TAPR Open Hardware License (www.tapr.org/OHL).

If you make any modification to this board, it would be great if you could let
me know at mail@dbrgn.ch.

## KiCad design backplane.kicad_pcb

Parts:
C1, C3: C; C_1206
D1: LED_Blue; LED_1206
D2: LED_Yellow; LED_1206
D3: LED_Red; LED_1206
D4, D6: D; DO-214AC
D5: D_TVS; DO-214AA; Digikey SMBJ5.0A-E3/5BGICT-ND
F1: Polyfuse; C_1812; Digikey MF-MSMF250/16X-2CT-ND
J1, J2: I2C; header_1x5_unmarked
J3: SER; header_1x2_unmarked
J4, J5: PWR; TerminalBlock_Pheonix_MPT-2.54mm_2pol
J6: FAN; header_1x2_marked
J7: PPS; header_1x1_unmarked
Q4: Q_NMOS_GSD; SOT-23
Q5: Q_PMOS_GSD; SOT-23
R1: 82Ω 1/8W; R_1206
R2: 330Ω 1/8W; R_1206
R3: 220Ω 1/8W; R_1206
R4, R5, R9, R13: R; R_1206
R10, R11, R12: R; R_0805
SW1: SW_Push; SW_Mikroshop
U1: Raspberry_Pi_2_3; Pin_Header_Straight_2x20_Pitch2.54mm
U2: IC880A-SPI
U4: MP1584_MODULE; MP1584_MODULE_ZVEPOWER
U5: MCP3425A0T-E/CH; SOT-23-6
U6: SHTC3; SHTC1

Connections:
3.3V: C1.2, J1.4 (3.3V), J2.4 (3.3V), R4.1, R5.1, U1.1 (3V3), U1.17 (3V3), U5.5 (VDD), U6.1 (VDD)
5V: D4.1 (K), D5.1 (K), J1.5 (5V), J2.5 (5V), J6.2 (5V), Q5.2 (S), R10.1, U1.2 (5V), U1.4 (5V), U2.21 (VDD)
BTN: SW1.1, U1.32 (GPIO12)
CE0: U1.24 ((~SPI_CE0~)_GPIO8), U2.17 (NSS)
CLK: U1.23 ((SPI_SCLK)_GPIO11), U2.14 (CLK)
FAN: Q4.1 (G), R9.2, U1.12 (GPIO18_(GEN1))
GND: C1.1, D1.1 (K), D2.1 (K), D3.1 (K), D5.2 (A), J1.3 (GND), J2.3 (GND), J4.1 (GND), Q4.2 (S), R9.1, R12.2, R13.1, SW1.2, U1.9 (GND), U1.14 (GND), U1.20 (GND), U1.25 (GND), U1.30 (GND), U1.34 (GND), U1.39 (GND), U2.1 (GND), U2.12 (GND), U2.20 (GND), U2.22 (GND), U2.24 (GND), U4.4 (OUT-), U5.2 (VSS), U6.4 (VSS)
GPS_RST: U1.29 (GPIO5), U2.3 (nGPS_Reset)
GPS_SUP: U1.31 (GPIO6), U2.5 (EN_GPS_Supply)
IC880A_RST: U1.22 (GPIO25_(GEN6)), U2.13 (Reset)
LED1: R1.1, U1.40 (GPIO21)
LED2: R2.1, U1.38 (GPIO20)
LED3: R3.1, U1.36 (GPIO16)
MISO: U1.21 ((SPI_MISO)_GPIO9), U2.15 (MISO)
MOSI: U1.19 ((SPI_MOSI)_GPIO10), U2.16 (MOSI)
unnamed: D6.2 (A), F1.1, J4.2 (VCC), U4.3 (OUT+)
unnamed: C3.1, R11.2, R12.1, U5.6 (Vin-)
unnamed: C3.2, R10.2, R11.1, U5.1 (Vin+)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), J6.1 (GND), Q4.3 (D)
unnamed: D6.1 (K), J5.2 (VCC), U4.2 (IN+), U4.5 (EN)
unnamed: F1.2, Q5.3 (D)
unnamed: J5.1 (GND), U4.1 (IN-)
unnamed: Q5.1 (G), R13.2
PPS: J7.1, U2.19 (PPS)
RX: J3.2 (RX), U1.10 ((RXD0)_GPIO15)
SCL: J1.2 (SCL), J2.2 (SCL), R5.2, U1.5 ((SCL1)_GPIO3), U5.3 (SCL), U6.2 (SCL)
SDA: J1.1 (SDA), J2.1 (SDA), R4.2, U1.3 ((SDA1)_GPIO2), U5.4 (SDA), U6.3 (SDA)
TX: J3.1 (TX), U1.8 ((TXD0)_GPIO14)

Notes on the sheet:
Raspberry Pi
iC880A
LEDs
SHTC3 Sensor
I²C Breakouts
Power
ADC
DC Fan
Connector for a 5V DC fan with a flyback diode.
This is a 16-Bit Analog-to-Digital Converter that is wired up to measure the Raspberry Pi supply voltage.
The board includes a 5V power input/output connector as well as a MP1584 step-down voltage regulator for 6.7-28V input.
The Sensirion SHTC3 sensor measures both temperature and humidity.
Button
A simple button connected to GPIO12. It could be programmed to shut down the Rpi on button press. Note that you need to enable the internal pull-up for the button to work.
Additionally, the parts are protected against voltage spikes by a resettable fuse and a TVS diode, and against reverse polarity by a MOSFET.
Accuracy SHTC3: ±0.2°C / ±2%RH
I²C Pull-Ups

Board: 2 copper layers, 93.9 x 83.8 mm, 34 parts (0 on the bottom side), 31 nets.

## Commit log

2017-02-04 Add README
2017-02-05 More ground connections and thicker power tracks
2017-02-05 Fixes
2017-02-05 Add text to PCB
2017-02-06 Remove GPS header (fixes #1)
2017-02-06 Add SHT21 to schema
2017-02-06 README update
2017-02-07 Re-add OSHW logo
2017-02-07 Add SHT21 sensor
2017-02-07 Add Raspberry Pi mounting holes
2017-02-07 Nicer keepout area around sensor
2017-02-08 Nicer labels
2017-02-08 Raspberry Pi GPIO numbers
2017-02-08 I2C pullups
2017-02-08 Add silkscreen label for iC880A-SPI
2017-02-08 Move labels
2017-02-08 More mounting holes
    Fixes #2
2017-02-08 Licensing
2017-02-08 Mention KiCad
2017-02-08 Second I²C header and various improvements
    Fixes #5
2017-02-08 Add 3D stuff
2017-02-09 Correct 3D models
2017-02-10 Start adding fan connectors
2017-02-10 Add pins for DC fan
2017-02-10 Add schema
2017-02-10 Switch PWM pin for fan
2017-02-11 Started BOM.csv
2017-02-11 Small changes
2017-02-11 Add Github URL to back side
2017-02-11 Start integrating MP1584 dc converter board
2017-02-11 Use screw terminal for PWR
2017-02-11 Improvements
2017-02-11 Change annotation of LED MOSFETs
2017-02-11 Move LEDs closer together
2017-02-12 Integrate step-down module
2017-02-12 Add Capacitors_THT submodule
2017-02-12 Add capacitor to schema
2017-02-13 Start working on variant
2017-02-13 Pulldowns
2017-02-18 More routing
2017-02-18 Finish routing
2017-02-18 Fix capacitor footprint
2017-02-18 Show rendered-components.png in README
2017-02-18 Improve README
2017-02-19 Simplify silkscreen text
2017-02-19 Add pull-down to fan MOSFET
2017-02-19 Keepout zone behind sensor
2017-02-19 Replace THT diode with SMD version
2017-02-19 Update renderings
2017-02-19 Update BOM
2017-02-19 Improve silkscreen
2017-02-19 Small change
2017-03-14 Fix footprint of iC880A-SPI
2017-03-14 Fix NMOS parts in schema
2017-03-14 Fix MOSFET
    Unfortunately the traces now look a bit ugly because of non-ideal
    routing, but this way I can re-use the stencil.
    Fixes #11
2017-03-14 Make tracks a bit nicer
2017-04-10 Fix capacitor silkscreen
2017-04-10 Larger holes (2.75 -> 2.95), fixes #12
2017-04-14 Move regulator away from iC880A RF area
    Fixes #13
2017-04-14 Start splitting up schema with labels
2017-04-14 Netlabel ALL THE THINGS
2017-04-14 Add ADC (refs #14)
2017-04-15 Assign footprints to ADC (refs #14)
2017-04-15 Add ADC to board (fixes #14)
2017-04-15 Fix position of R4
2017-04-15 Clean up schematics
2017-04-15 Update netlist
2017-04-15 Start working on button (#15)
2017-04-18 Add button footprint and fix some NCs
    Fixes #15
2017-04-19 Improve and simplify traces
2017-04-19 Update schematics and renderings
2017-04-20 Add more groundplane vias
2017-04-20 Add protection diode and polyfuse to schematics
2017-04-20 Protection circuit and re-routing
    This will require a new stencil.
2017-04-21 Smaller footprints for ADC
2017-04-21 Small cleanup
2017-04-21 Change net names for RX/TX
2017-04-21 Update feature list
2017-04-23 Add some datasheets
2017-04-23 Fix DO214 3D model orientation
2017-04-23 Improve some silkscreen labels
2017-04-23 Move up C2 footprint
2017-04-23 Improve trace nearby via
2017-05-06 Fix voltage divisor resistance values
    Previous values were wrong and would saturate the ADC.
2017-05-06 Add shop link to README
2017-05-31 Add first version of testsuite
2017-05-31 Testsuite: Fixes
2017-06-02 Testsuite: More fixes, add ADC test
2017-06-16 Add self locking header test board (#17)
2017-06-16 Fix button footprint (fixes #18)
2017-06-16 v1.2
2017-07-20 Add schematics for v1.2
2017-08-10 Update revision
2017-10-10 New kicad version
2017-10-10 Add iC880A mounting hole (fixes #21)
2017-10-10 Remove single-pad nets
2017-10-10 Add PPS pin (fixes #20)
2017-10-10 Prepare v1.4
2017-10-11 Fix rotation of 3D objects
2017-11-19 Remove headertest board
2017-11-19 Fix 3D models, update renderings
2017-11-19 Update schematics link in README
2017-12-14 Export schematics v1.4
2018-01-12 Nicer traces
2018-01-17 Simplify LEDs (fixes #19)
    Also, make pin 1 dot for SHT21 bigger.
2018-01-17 Increase restring of MP1584 module (#23)
2018-01-17 More Swissness :wink:
2018-01-17 Increase 2x20 pin header restrings (#23)
    Also update LED resistor values
2018-01-17 Update date
2018-01-17 Update license date
2018-01-17 Increase iC880A restrings (#23)
    Also remove dangling trace
2018-01-17 Increase pin header restrings (#23)
2018-01-17 Rebuild planes
2018-01-17 Prepare version 1.5
2018-02-11 Remove testscripts
2018-03-04 Add v1.5 schematics
2018-03-26 Update for Zvepower regulator
    It has castellated edges and is slightly smaller.
2018-05-09 Add SHTC1 footprint / symbol
2018-05-09 Schematics: Add SHTC1
2018-05-09 Add SHTC3 in parallel to SHT21
2018-05-09 Update version string on PCB
2018-05-09 Move Vin connectors out of the way (#26)
    It should be impossible to short with the USB/Ethernet connectors.
2018-05-09 Center MP1584 silkscreen text
2018-06-07 Update schematics
2018-11-01 Add v2 minor variant
2019-07-16 Upgrade file format
2019-07-16 Version 2.1
2019-07-16 Fix some DRC warnings
    - Polygon with SHT cutouts was not perfectly closed
2019-07-16 Silkscreen improvements: SHTC3 dot
2019-07-16 Silkscreen improvements: ADC dot
2019-07-16 Remove SHT21
2019-07-16 Remove C2
    It was always optional and not required in practice.
2019-07-16 Fix 3D models
    KiCAD keeps breaking them on every version update...
2019-07-16 Show some more designators on silkscreen, generate v2.1
2019-09-02 Add schematics v2.1
